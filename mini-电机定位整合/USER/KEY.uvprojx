# Keil uVision project KEY.uvprojx, settings and files
target KEY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\Point2Point;..\HARDWARE\CAN;..\HARDWARE\PID;..\HARDWARE\LCD;..\HARDWARE\Laser;..\HARDWARE\TIMER;..\HARDWARE\move_base;..\HARDWARE\CANRecieve;..\HARDWARE\ps2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Point2Point/: point2point.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/move_base/: move_base.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CANRecieve/: CAN_Receive.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ps2/: ps2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c
    ../../C8T6/CORE/: startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_dma.c
  group README
    ../: README.TXT
